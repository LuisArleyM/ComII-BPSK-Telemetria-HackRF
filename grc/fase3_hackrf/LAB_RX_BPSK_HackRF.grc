options:
  parameters:
    author: Luis Arley Martinez Caballero - Johan Sebastian Gomez Hernandez
    description: 'Receptor BPSK: 2 MS/s -> 64 kS/s, AGC, FLL, PFB clock sync, Costas, decision, referencia PRBS-15 alineada.'
    generate_options: qt_gui
    id: LAB_RX_BPSK_HackRF
    output_language: python
    title: LAB RX BPSK HackRF - sincronia + BER en condicion limpia
  states: {}

blocks:
- name: Rs
  id: variable
  parameters:
    comment: Tasa de simbolos (igual al Tx)
    value: '8000'
  states: {}
- name: Sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: bb_rate = 64 kS/s
    value: Rs*Sps
  states: {}
- name: tabla_bpsk
  id: variable
  parameters:
    comment: 'Mapeo BPSK del escenario: bit0 -> -1, bit1 -> +1'
    value: (-1+0j, 1+0j)
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_bpsk)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    comment: 'BPSK: Rb = Rs = 8 kb/s'
    value: Rs*bps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    comment: 'Lazo de Costas: 2pi/200 (elegido en el estudio de lazos)'
    value: 2*math.pi/200
  states: {}
- name: fll_bw
  id: variable
  parameters:
    comment: 'FLL: 2pi/2500 (elegido en el estudio de lazos)'
    value: 2*math.pi/2500
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Frecuencia RF asignada (enlace confinado/autorizado)
    value: 960e6
  states: {}
- name: lo_off
  id: variable
  parameters:
    comment: LO desplazado 200 kHz para sacar la senal del pico DC del HackRF
    value: 200e3
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: Tasa del HackRF (>= 2 MS/s)
    value: 2e6
  states: {}
- name: hackrf_rx
  id: variable
  parameters:
    value: '"hackrf=0"'
  states: {}
- name: prbs_seed
  id: variable
  parameters:
    comment: Semilla PRBS-15 (igual en Tx y Rx)
    value: '32767'
  states: {}
- name: const_bpsk
  id: variable_constellation
  parameters:
    const_points: tabla_bpsk
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    label: Roll-off beta (igual al Tx)
    start: '0.1'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: Rx IF gain / LNA HackRF (0-40 dB, pasos de 8)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: Rx BB gain / VGA HackRF (0-62 dB, pasos de 2)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: hackrf_rx
    bb_gain0: rx_vga
    comment: 'HackRF Rx: LO = fc + 200 kHz. RF amp (gain0) apagado. Usar atenuador si va por cable'
    freq0: fc + lo_off
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_lna
    sample_rate: radio_rate
    sync: none
    type: fc32
  states: {}
- name: rx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    comment: Trae la senal de -200 kHz a 0 Hz (compensa el LO desplazado)
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: rx_resampler
  id: rational_resampler_xxx
  parameters:
    comment: 'Adaptacion de tasa: 2 MS/s x 4/125 = 64 kS/s = bb_rate'
    decim: '125'
    interp: '4'
    type: ccc
  states: {}
- name: agc_entrada
  id: analog_agc_xx
  parameters:
    comment: 'AGC1: normaliza el nivel de entrada (cambia con la ganancia RF y con el AWGN del barrido)'
    gain: '1.0'
    max_gain: '1000'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    comment: 'FLL de borde de banda: corrige el offset de frecuencia Tx-Rx (cristales distintos)'
    filter_size: '44'
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: fll_bw
  states: {}
- name: pfb_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: 'Filtro acoplado RRC (banco polifasico) + recuperacion de reloj: 1 muestra/simbolo'
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: firdes.root_raised_cosine(nfilts, nfilts*Sps, 1.0, beta, span*Sps*nfilts)
    type: ccf
  states: {}
- name: agc_simbolos
  id: analog_agc_xx
  parameters:
    comment: 'AGC2: amplitud de simbolo ~1 para que la ganancia del lazo de Costas sea estable'
    gain: '1.0'
    max_gain: '100'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    comment: 'Lazo de Costas orden 2 (BPSK): fase residual. Ambiguedad de 180 grados'
    w: costas_bw
    order: '2'
  states: {}
- name: decisor_bpsk
  id: digital_constellation_decoder_cb
  parameters:
    comment: 'Decision BPSK: -1 -> bit 0, +1 -> bit 1 (mismo mapeo del Tx)'
    constellation: const_bpsk
  states: {}
- name: hz_por_rad
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad/muestra -> Hz
    const: samp_rate/(2*math.pi)
    type: float
  states: {}
- name: offset_hz
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Offset
    max: '5000'
    min: '-5000'
    name: '"Offset de frecuencia Tx-Rx estimado por la FLL"'
    type: float
    unit1: Hz
    update_time: '0.20'
  states: {}
- name: null_fll
  id: blocks_null_sink
  parameters:
    comment: Salidas de diagnostico no usadas (fase y error de la FLL)
    num_inputs: '2'
    type: float
  states: {}
- name: rx_const_sincronizada
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"RX constelacion recuperada (portadora y reloj)"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rx_espectro
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Rx banda base
    name: '"RX espectro a 64 kS/s (despues de la adaptacion de tasa)"'
    type: complex
  states: {}
- name: rx_ref
  id: epy_block
  parameters:
    comment: Regenera la PRBS-15 del Tx y la alinea por correlacion (resuelve tambien la ambiguedad de 180 grados)
    _source_code: |
      """
      e_Ref_PRBS15_Rx
      Regenera en el RECEPTOR la secuencia de bits transmitida (PRBS-15) y la
      alinea automaticamente con los bits recuperados.

      Entrada 0 : bits recuperados por el receptor (byte 0/1), despues de la
                  decision BPSK.
      Salida 0  : bits Tx de referencia regenerados y alineados (byte 0/1).
                  -> se conecta a la entrada 0 de e_BER_Curve.
      Salida 1  : BER acumulada desde el ultimo enganche (float).
                  -1 mientras no hay enganche. Sirve como evidencia de la
                  condicion limpia (BER ~ 0) sin barrido de ruido.

      Por que hace falta (Guia 4, "Tx y Rx en computadores diferentes"):
          Con Tx y Rx en computadores distintos, el instante en que arranca cada
          flujograma es arbitrario, por lo que el retardo Tx->Rx expresado en bits
          cambia en cada ejecucion. Un delay_bits fijo no sirve. Este bloque hace
          la misma tarea que ajustar delay_bits, pero de forma automatica:

          1) Adquisicion: toma los ultimos W bits recibidos y calcula su
             correlacion circular con la PRBS-15 completa (FFT). El maximo de
             |correlacion| da la fase de la secuencia y su signo da la polaridad
             (BPSK tiene ambiguedad de 180 grados: el lazo de Costas puede
             engancharse invertido y entregar todos los bits negados).
             Se acepta el enganche si las discrepancias son <= thr_acq*W.
             Con W=256 y thr_acq=0.25: P(falso enganche) ~ 1e-11 y
             P(no enganchar con BER real 15 %) ~ 1e-5.
          2) Seguimiento: genera la referencia continuando la fase hallada,
             independiente de los bits recibidos (los errores se cuentan de
             verdad, no se "corrigen").
          3) Saltos de ciclo de 180 grados: a baja Eb/N0 el lazo de Costas puede
             saltar media vuelta y desde ese instante TODOS los bits salen
             invertidos. Si en los ultimos Np = 32 bits hay al menos 75 % de
             discrepancias (imposible por ruido: con BER real de 15 % la
             probabilidad es ~1e-12), se invierte la polaridad de la referencia.
             Cada salto cuesta ~25 bits erroneos, que SI se cuentan; es el mismo
             efecto que tendria un sistema real que resuelve la ambiguedad con
             una secuencia conocida. Los saltos se cuentan en self.n_saltos.
          4) Perdida: si en una ventana de D bits la tasa de discrepancia supera
             thr_loss (35 %) con la polaridad ya corregida (deslizamiento de reloj:
             se gano o se perdio un bit), se vuelve a adquirir. Mientras tanto la
             referencia sigue la fase anterior, de modo que los bits de ese
             intervalo cuentan como errores reales.

          Antes del primer enganche la salida es el complemento de los bits
          recibidos (BER = 1): si no hay senal, la curva lo muestra en vez de
          aparentar BER = 0.

          Al engancharse imprime el retardo equivalente en bits (lo que habria que
          poner en delay_bits si el Tx empezara en el mismo instante que el Rx) y
          la polaridad detectada.

      La salida 0 es 1:1 con la entrada (sync_block), por lo que el conteo de bits
      de e_BER_Curve y la segmentacion del barrido de e_EbN0_Sweep no se alteran.
      """

      import numpy as np
      from gnuradio import gr


      def prbs15(seed=0x7FFF):
          """Mismo generador que e_PRBS15_Tx (x^15 + x^14 + 1)."""
          state = int(seed) & 0x7FFF
          if state == 0:
              state = 0x7FFF
          out = np.empty(32767, dtype=np.uint8)
          for i in range(32767):
              newbit = ((state >> 14) ^ (state >> 13)) & 1
              state = ((state << 1) | newbit) & 0x7FFF
              out[i] = newbit
          return out


      class blk(gr.sync_block):
          def __init__(self, seed=32767, W=256, thr_acq=0.25, D=512, thr_loss=0.35, Np=32, thr_pol=0.75):
              gr.sync_block.__init__(
                  self,
                  name='e_Ref_PRBS15_Rx',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8, np.float32]
              )
              self.seq = prbs15(int(seed))
              self.L = len(self.seq)
              self.W = int(W)
              self.thr_acq = float(thr_acq)
              self.D = int(D)
              self.thr_loss = float(thr_loss)
              self.Np = int(Np)
              self.thr_pol_n = int(np.ceil(float(thr_pol) * self.Np))
              self.pbuf = np.zeros(self.Np, dtype=np.int8)   # ventana circular de errores
              self.pidx = 0
              self.psum = 0
              self.pcnt = 0
              self.n_saltos = 0

              # FFT conjugada de la PRBS en +-1 para la correlacion circular.
              seq_pm = 1.0 - 2.0 * self.seq.astype(np.float64)
              self.F_seq = np.fft.fft(seq_pm)

              self.locked = False
              self.ever_locked = False
              self.phase = 0          # indice de la PRBS que corresponde al proximo bit
              self.inv = 0            # 1 si el receptor entrega los bits invertidos
              self.hist = np.zeros(0, dtype=np.uint8)
              self.nrx = 0            # bits recibidos desde el arranque
              self.win_err = 0
              self.win_cnt = 0
              self.err_lock = 0       # errores desde el ultimo enganche
              self.cnt_lock = 0
              self.n_locks = 0
              self.ber_out = -1.0

          # ------------------------------------------------------------------
          def _acquire(self, window):
              W = len(window)
              w_pm = np.zeros(self.L, dtype=np.float64)
              w_pm[:W] = 1.0 - 2.0 * window.astype(np.float64)
              # corr[p] = sum_k seq_pm[(p+k) % L] * w_pm[k]
              corr = np.real(np.fft.ifft(self.F_seq * np.conj(np.fft.fft(w_pm))))
              p0 = int(np.argmax(np.abs(corr)))
              c = corr[p0]
              mism = int(round((W - abs(c)) / 2.0))
              if mism <= self.thr_acq * W:
                  inv = 1 if c < 0 else 0
                  return True, (p0 + W) % self.L, inv, mism
              return False, 0, 0, mism

          def _reset_pol(self):
              self.pbuf[:] = 0
              self.pidx = 0
              self.psum = 0
              self.pcnt = 0

          def _seguir_polaridad(self, base, rx):
              """Referencia = base XOR polaridad, invirtiendo la polaridad cuando en
              los ultimos Np bits hay >= thr_pol*Np discrepancias (salto de 180 grados)."""
              ref = base ^ self.inv
              if self.Np <= 0:
                  return ref
              err = (ref != rx).astype(np.int8)
              Np, thr = self.Np, self.thr_pol_n
              # Camino rapido (casi siempre): ni sumando todo el bloque se llega al umbral.
              if int(err.sum()) + self.psum < thr:
                  if len(err) >= Np:
                      self.pbuf[:] = err[-Np:]
                      self.pidx = 0
                      self.psum = int(self.pbuf.sum())
                      self.pcnt = Np
                  else:
                      for e in err.tolist():
                          self.psum += e - int(self.pbuf[self.pidx])
                          self.pbuf[self.pidx] = e
                          self.pidx = (self.pidx + 1) % Np
                          self.pcnt = min(self.pcnt + 1, Np)
                  return ref
              # Camino lento: bit a bit, con posible inversion de polaridad.
              buf = self.pbuf
              pidx, psum, pcnt, inv = self.pidx, self.psum, self.pcnt, self.inv
              b = base.tolist()
              r = rx.tolist()
              out = np.empty(len(b), dtype=np.uint8)
              for i in range(len(b)):
                  e = 1 if (b[i] ^ inv) != r[i] else 0
                  psum += e - int(buf[pidx])
                  buf[pidx] = e
                  pidx = (pidx + 1) % Np
                  if pcnt < Np:
                      pcnt += 1
                  if pcnt == Np and psum >= thr:
                      inv ^= 1
                      self.n_saltos += 1
                      buf[:] = 0
                      psum = 0
                      pcnt = 0
                  out[i] = b[i] ^ inv
              self.pidx, self.psum, self.pcnt, self.inv = pidx, psum, pcnt, inv
              return out

          def work(self, input_items, output_items):
              rx_all = np.asarray(input_items[0], dtype=np.uint8) & 1
              out_ref = output_items[0]
              out_ber = output_items[1]
              n = min(len(rx_all), len(out_ref), len(out_ber))
              if n <= 0:
                  return 0

              pos = 0
              while pos < n:
                  if self.locked:
                      # Seguimiento, en sub-bloques que terminan en la frontera de
                      # la ventana de deteccion de perdida (D bits).
                      m = min(n - pos, self.D - self.win_cnt)
                      idx = (self.phase + np.arange(m, dtype=np.int64)) % self.L
                      rx = rx_all[pos:pos + m]
                      ref = self._seguir_polaridad(self.seq[idx], rx)
                      out_ref[pos:pos + m] = ref
                      err = int(np.count_nonzero(ref != rx))
                      self.err_lock += err
                      self.cnt_lock += m
                      self.win_err += err
                      self.win_cnt += m
                      self.phase = int((self.phase + m) % self.L)
                      self.nrx += m
                      self.ber_out = self.err_lock / float(max(self.cnt_lock, 1))
                      out_ber[pos:pos + m] = self.ber_out
                      pos += m
                      if self.win_cnt >= self.D:
                          if self.win_err > self.thr_loss * self.win_cnt:
                              self.locked = False
                              self.hist = np.zeros(0, dtype=np.uint8)
                              print('[RX-REF] Perdida de alineacion (%.0f %% de discrepancia en %d bits). '
                                    'Re-adquiriendo...' % (100.0 * self.win_err / self.win_cnt, self.win_cnt))
                          self.win_err = 0
                          self.win_cnt = 0
                  else:
                      # Sin enganche: se intenta adquirir cada W/2 bits nuevos.
                      if len(self.hist) < self.W:
                          m = min(n - pos, self.W - len(self.hist))
                      else:
                          m = min(n - pos, max(1, self.W // 2))
                      rx = rx_all[pos:pos + m]
                      idx = (self.phase + np.arange(m, dtype=np.int64)) % self.L
                      if self.ever_locked:
                          ref = self.seq[idx] ^ self.inv   # se cuentan errores reales
                      else:
                          ref = rx ^ 1                     # sin senal: BER = 1
                      out_ref[pos:pos + m] = ref
                      out_ber[pos:pos + m] = self.ber_out
                      self.phase = int((self.phase + m) % self.L)
                      self.nrx += m
                      self.hist = np.concatenate((self.hist, rx))[-self.W:]
                      pos += m
                      if len(self.hist) >= self.W:
                          ok, p_next, inv, mism = self._acquire(self.hist)
                          if ok:
                              self.locked = True
                              self.ever_locked = True
                              self.phase = p_next
                              self.inv = inv
                              self.err_lock = 0
                              self.cnt_lock = 0
                              self.win_err = 0
                              self.win_cnt = 0
                              self.n_locks += 1
                              self._reset_pol()
                              # Corrige hacia atras la referencia de los bits de la
                              # ventana que aun pertenecen a esta llamada.
                              a = max(0, pos - self.W)
                              k = pos - a
                              back = (p_next - k + np.arange(k, dtype=np.int64)) % self.L
                              out_ref[a:pos] = self.seq[back] ^ inv
                              delay = int((self.nrx - self.phase) % self.L)
                              print('[RX-REF] Enganche #%d: %d/%d discrepancias en la ventana, '
                                    'polaridad %s, retardo equivalente = %d bits (mod %d).'
                                    % (self.n_locks, mism, self.W,
                                       'INVERTIDA (180 grados)' if inv else 'normal',
                                       delay, self.L))
                              self.hist = np.zeros(0, dtype=np.uint8)
              return n
    seed: prbs_seed
    W: '256'
    thr_acq: '0.25'
    D: '512'
    thr_loss: '0.35'
    Np: '32'
    thr_pol: '0.75'
  states: {}
- name: null_ref
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: ber_limpia
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    max: '0.5'
    name: '"BER en condicion limpia (desde el enganche) [-1 = sin enganche]"'
    type: float
    update_time: '0.20'
  states: {}

connections:
- [hackrf_source, '0', rx_desplaza, '0']
- [rx_desplaza, '0', rx_resampler, '0']
- [rx_resampler, '0', agc_entrada, '0']
- [agc_entrada, '0', fll, '0']
- [fll, '0', pfb_sync, '0']
- [pfb_sync, '0', agc_simbolos, '0']
- [agc_simbolos, '0', costas, '0']
- [costas, '0', decisor_bpsk, '0']
- [fll, '1', hz_por_rad, '0']
- [hz_por_rad, '0', offset_hz, '0']
- [fll, '2', null_fll, '0']
- [fll, '3', null_fll, '1']
- [costas, '0', rx_const_sincronizada, '0']
- [rx_resampler, '0', rx_espectro, '0']
- [decisor_bpsk, '0', rx_ref, '0']
- [rx_ref, '0', null_ref, '0']
- [rx_ref, '1', ber_limpia, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
